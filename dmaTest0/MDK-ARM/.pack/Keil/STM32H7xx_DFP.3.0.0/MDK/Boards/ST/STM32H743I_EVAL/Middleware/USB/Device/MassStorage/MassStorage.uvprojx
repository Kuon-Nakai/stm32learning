# Keil uVision project MassStorage.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: MassStorage
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h743.sct
  group Source
    ./: MassStorage.c USBD_User_MSC_0.c USBD_User_MSC_1.c MemoryDiskImage.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./STM32CubeMX/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./STM32CubeMX/STCubeGenerated/Inc/: stm32h7xx_it.h
target Release (6160000::V6.16::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: as above
  output: MassStorage
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h743.sct
  link misc: --diag_suppress=L6314
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, File System:CORE 6.14.1, File System:CORE 6.14.1, File System:Drive:Memory Card 6.14.1, USB:CORE 6.15.0, USB:CORE 6.15.0, USB:Device 6.15.0, USB:Device:MSC 6.15.0, Board Support:Drivers:BUS 1.1.0, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:I/O 1.1.0, CMSIS Driver:MCI 1.7.0, CMSIS Driver:USB Device 1.5.0, Device:STM32Cube HAL:ADC 1.9.0, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:EXTI 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:I2C 1.9.0, Device:STM32Cube HAL:MDMA 1.9.0, Device:STM32Cube HAL:MMC 1.9.0, Device:STM32Cube HAL:PCD 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:SD 1.9.0, Device:STM32Cube HAL:SDRAM 1.9.0, Device:STM32Cube HAL:UART 1.9.0, Device:Startup 1.9.0
