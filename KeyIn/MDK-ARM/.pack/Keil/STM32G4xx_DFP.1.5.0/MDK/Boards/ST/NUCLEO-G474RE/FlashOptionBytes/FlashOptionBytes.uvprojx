# Keil uVision project FlashOptionBytes.uvprojx, settings and files
target STM32G4xx_SB_OPT (6160000::V6.16::ARMCLANG)
  device: STM32G491CETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x0001C000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FLashOptionBytes
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  scatter file: .\STM32G4xx_OPT.sct
  link misc: --diag_suppress L6305
  group Documentation
    ./: README.md
  group Source Group 1
    ./: STM32G4xx_DB_OPT.s STM32G4xx_SB_OPT.s
target STM32G4xx_DB_OPT (6160000::V6.16::ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FLashOptionBytes
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\STM32G4xx_OPT.sct
  link misc: --diag_suppress L6305
